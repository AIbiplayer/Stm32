/**
 * @file ShowShape.c
 * @brief 绘制图形函数
 * @date 2025/10/8
 */

#include <math.h>
#include "main.h"

static float target_arm_angle = 90; // 目标角度
static float target_base_angle = 135;
static float last_arm_angle = 90; // 上次角度
static float last_base_angle = 135;
static float real_arm_angle = 90; // 实时角度
static float real_base_angle = 135;
static float step_base; // 插值步长
static float step_arm; // 插值步长

static int32_t mode = 0; // 模式选择变量
static int interp_step = 0; // 插值步数计数器
const int cnt = 2; // 插值总步数
const float ts_dis = 0.3f; // 云台到白纸的距离

extern TIM_HandleTypeDef htim3;

/**
 * @brief 设置偏航舵机角度
 * @param yaw_angle 目标角度，范围0-270度
 */
void Yaw_SetAngle(float yaw_angle)
{
    __HAL_TIM_SET_COMPARE(&htim3, TIM_CHANNEL_1, (yaw_angle / 270) * 2000 + 500);
}

/**
 * @brief 设置俯仰舵机角度
 * @param pitch_angle 目标角度，范围0-180度
 */
void Pitch_SetAngle(float pitch_angle)
{
    __HAL_TIM_SET_COMPARE(&htim3, TIM_CHANNEL_2, (pitch_angle / 180) * 2000 + 500);
}

/**
 * @brief 计算偏航舵机目标角度
 * @param ts 云台到白纸的距离
 * @param x_point 白纸上点的x坐标
 * @return 计算得到的偏航舵机角度
 */
float base_x(float ts, float x_point)
{
    float angle = 0;
    angle = 135.0f - (atan(x_point / ts)) * 57.3f;
    return angle;
}

/**
 * @brief 计算俯仰舵机目标角度
 * @param ts 云台到白纸的距离
 * @param y_point 白纸上点的y坐标
 * @return 计算得到的俯仰舵机角度
 */
float base_y(float ts, float y_point)
{
    float angle = 0;
    angle = 90.0f - (atan(y_point / ts)) * 57.3f;
    return angle;
}

/**
 * @brief 绘制三角形图案
 * @note 该函数通过插值计算舵机角度，实现平滑运动
 */
void ShowTriangle(void)
{
    if (interp_step == 0) // 仅仅在插值时开始更新目标角度
    {
        if (mode <= 0)
        {
            target_base_angle = base_x(ts_dis, 0);
            target_arm_angle = base_y(ts_dis, 0);
        }
        else if (mode == 30)
        {
            target_base_angle = base_x(ts_dis, 0.0);
            target_arm_angle = base_y(ts_dis, 0.05);
        }
        else if (mode == 30 * 2)
        {
            target_base_angle = base_x(ts_dis, -0.03);
            target_arm_angle = base_y(ts_dis, 0.0);
        }
        else if (mode == 30 * 3)
        {
            target_base_angle = base_x(ts_dis, 0.03);
            target_arm_angle = base_y(ts_dis, 0.0);
            mode = 0; // mode清零以循环绘制三角形
        }
        // 计算插值步长
        step_base = (target_base_angle - last_base_angle) / cnt;
        step_arm = (target_arm_angle - last_arm_angle) / cnt;
        last_base_angle = target_base_angle;
        last_arm_angle = target_arm_angle;
    }
    // 插值
    real_arm_angle = real_arm_angle + step_arm;
    real_base_angle = real_base_angle + step_base;

    Yaw_SetAngle(real_base_angle);
    Pitch_SetAngle(real_arm_angle);
    // 更新插值步数和mode
    interp_step++;
    if (interp_step >= cnt)
    {
        interp_step = 0;
        mode++;
    }
}

/**
 * @brief 绘制圆形图案
 * @note 该函数通过计算圆周上的点，设置舵机角度，实现绘制圆形
 */
void ShowCircal(void)
{
    static float theta = 0.0f;
    static const float radius = 0.05f; // 绘制圆的半径
    static const int steps = 400; // 画圆的步数
    float theta_step = 2.0f * 3.1415926535f / steps; // 每步的角度增量

    if (mode < steps)
    {
        // 计算目标角度
        target_base_angle = base_x(ts_dis, radius * cos(theta));
        target_arm_angle = base_y(ts_dis, radius * sin(theta));
        // 计算每步的增量
        step_base = (target_base_angle - last_base_angle) / 100.0f;
        step_arm = (target_arm_angle - last_arm_angle) / 100.0f;
        // 更新上一次的角度
        last_base_angle = target_base_angle;
        last_arm_angle = target_arm_angle;
        // 增加角度参数
        theta += theta_step;
        mode++;
    }
    else
    {
        // 一圈完成后重置
        mode = 0;
        theta = 0.0f;
    }
    // 插值计算实际角度
    real_arm_angle = target_arm_angle;
    real_base_angle = target_base_angle;

    Yaw_SetAngle(real_base_angle);
    Pitch_SetAngle(real_arm_angle);
}

/**
 * @brief 绘制正弦波图案
 * @note 该函数通过计算正弦函数上的点，设置舵机角度，实现绘制正弦波
 */
void ShowSin(void)
{
    static float theta = 0.0f;
    static const float radius = 0.03f;
    static const int steps = 400;
    float theta_step = 0.4 / steps;
    static uint8_t low_fre = 0;
    low_fre = !low_fre;

    if (mode < steps)
    {
        target_base_angle = base_x(ts_dis, -0.2 + theta);
        target_arm_angle = base_y(ts_dis, radius * sin(30 * 3.1415926f * theta));

        step_base = (target_base_angle - last_base_angle) / 100.0f;
        step_arm = (target_arm_angle - last_arm_angle) / 100.0f;

        last_base_angle = target_base_angle;
        last_arm_angle = target_arm_angle;
        // 增加角度参数
        theta += theta_step;
        mode++;
    }
    else if (mode >= steps && mode <= steps + 100)
    {
        mode++;
        return;
    }
    else
    {
        mode = 0;
        theta = 0.0f;
    }
    real_arm_angle = target_arm_angle;
    real_base_angle = target_base_angle;

    Yaw_SetAngle(real_base_angle);
    Pitch_SetAngle(real_arm_angle);
}
